# Keil uVision project Blinkenstein.uvprojx, settings and files
target nRF52832-Blinkenstein (5060300::V5.06 update 3 (build 300)::ARMCC)
  device: nRF52832_xxAA Nordic Semiconductor
  pack: NordicSemiconductor.nRF_DeviceFamilyPack.8.12.0
  cpu: IRAM(0x20000000,0x10000) IROM(0x00000000,0x80000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: Blinkenstein +hex
  c flags: Optim=1 OneElfS=1 uC99=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: NRF52 NRF52832 NRF52832_XXAA NRF52_PAN_12 NRF52_PAN_15 NRF52_PAN_20 NRF52_PAN_31 NRF52_PAN_36 NRF52_PAN_51 NRF52_PAN_54 NRF52_PAN_55 NRF52_PAN_58 NRF52_PAN_64 NRF52_PAN_74 BLE_STACK_SUPPORT_REQD NRF_SD_BLE_API_VERSION=4 S132 SOFTDEVICE_PRESENT SVC_INTERFACE_CALL_AS_NORMAL_FUNCTION NRF_DFU_DEBUG_VERSION NRF_DFU_SETTINGS_VERSION=1 ARM_MATH_CM4 DEBUG  CONFIG_GPIO_AS_PINRESET
  c include: .;.\;.\BLE;.\BLE\ble_advertising;.\BLE\ble_db_discovery;.\BLE\ble_dtm;.\BLE\ble_racp;.\BLE\ble_radio_notification;.\BLE\ble_services;.\BLE\common;.\BLE\nrf_ble_gatt;.\BLE\nrf_ble_qwr;.\BLE\peer_manager;.\Config;.\Device;.\Ext_Drivers;.\nRF_Drivers;.\nRF_Drivers\clock;.\nRF_Drivers\common;.\nRF_Drivers\delay;.\nRF_Drivers\gpiote;.\nRF_Drivers\hal;.\nRF_Drivers\i2s;.\nRF_Drivers\pdm;.\nRF_Drivers\ppi;.\nRF_Drivers\systick;.\nRF_Drivers\timer;.\nRF_Drivers\twi_master;.\nRF_Drivers\uart;.\nRF_Libraries\atomic;.\nRF_Libraries\atomic_fifo;.\nRF_Libraries\balloc;.\nRF_Libraries\bootloader;.\nRF_Libraries\button;.\nRF_Libraries\crc16;.\nRF_Libraries\crc32;.\nRF_Libraries\experimental_section_vars;.\nRF_Libraries\fds;.\nRF_Libraries\fstorage;.\nRF_Libraries\gpiote;.\nRF_Libraries\log;.\nRF_Libraries\log\src;.\nRF_Libraries\queue;.\nRF_Libraries\scheduler;.\nRF_Libraries\svc;.\nRF_Libraries\strerror;.\nRF_Libraries\timer;.\nRF_Libraries\twi;.\nRF_Libraries\uart;.\nRF_Libraries\util;.\SoftDevice;.\SoftDevice\nrf52;.\SoftDevice\softdevice_handler;.\Ext_Libraries;.\Ext_Libraries\segger_rtt;.\Ext_Drivers;.\Ext_Drivers\LIS3DH;.\Ext_Drivers\ws2812b;.\BLE\ble_services\ble_nus
  asm define: NRF52 NRF52832 NRF52832_XXAA NRF52_PAN_12 NRF52_PAN_15 NRF52_PAN_20 NRF52_PAN_31 NRF52_PAN_36 NRF52_PAN_51 NRF52_PAN_54 NRF52_PAN_55 NRF52_PAN_58 NRF52_PAN_64 NRF52_PAN_74 BLE_STACK_SUPPORT_REQD NRF_SD_BLE_API_VERSION=4 S132 SOFTDEVICE_PRESENT SVC_INTERFACE_CALL_AS_NORMAL_FUNCTION NRF_DFU_DEBUG_VERSION NRF_DFU_SETTINGS_VERSION=1 CONFIG_GPIO_AS_PINRESET ARM_MATH_CM4 DEBUG
  library: MicroLIB
  memory RVCT4: ROM 0x1f000 size 0x61000
  memory RVCT9: RAM 0x20002060 size 0xdfa0
  group Application
    ./: main.c BlinkLib.c BlinkLib.h GPIOHandler.c GPIOHandler.h
  group nRF Drivers
    ./nRF_Drivers/common/: nrf_drv_common.c
    ./nRF_Drivers/gpiote/: nrf_drv_gpiote.c
    ./nRF_Drivers/i2s/: nrf_drv_i2s.c
    ./nRF_Drivers/pdm/: nrf_drv_pdm.c
    ./nRF_Drivers/ppi/: nrf_drv_ppi.c
    ./nRF_Drivers/systick/: nrf_drv_systick.c
    ./nRF_Drivers/timer/: nrf_drv_timer.c
    ./nRF_Drivers/twi_master/: nrf_drv_twi.c
    ./nRF_Drivers/uart/: nrf_drv_uart.c
  group nRF Libraries
    ./nRF_Libraries/button/: app_button.c
    ./nRF_Libraries/log/src/: nrf_log_backend_serial.c nrf_log_frontend.c
    ./nRF_Libraries/scheduler/: app_scheduler.c
    ./nRF_Libraries/timer/: app_timer.c
    ./nRF_Libraries/twi/: app_twi.c
    ./nRF_Libraries/uart/: app_uart.c
    ./nRF_Libraries/util/: app_error.c app_error_weak.c app_util_platform.c nrf_assert.c sdk_mapped_flags.c
    ./nRF_Libraries/fds/: fds.c
    ./nRF_Libraries/fstorage/: fstorage.c
    ./nRF_Libraries/strerror/: nrf_strerror.c
    ./nRF_Libraries/queue/: nrf_queue.c
  group Config
    ./Config/: sdk_config.h
    ./: hardware.h
  group BLE
    ./BLE/ble_advertising/: ble_advertising.c
    ./BLE/common/: ble_advdata.c ble_conn_params.c ble_conn_state.c ble_srv_common.c
    ./BLE/nrf_ble_gatt/: nrf_ble_gatt.c
    ./BLE/peer_manager/: gatt_cache_manager.c gatts_cache_manager.c id_manager.c peer_data_storage.c peer_database.c peer_id.c peer_manager.c pm_buffer.c pm_mutex.c security_dispatcher.c security_manager.c
  group BLE Services
    ./BLE/ble_services/ble_nus/: ble_nus.c
  group Ext Libraries
    ./Ext_Libraries/segger_rtt/: RTT_Syscalls_KEIL.c SEGGER_RTT.c SEGGER_RTT_printf.c
  group SoftDevice
    ./SoftDevice/softdevice_handler/: softdevice_handler_appsh.c softdevice_handler.c
  group Ext Drivers
    ./Ext_Drivers/ws2812b/: i2s_ws2812b_drive.c i2s_ws2812b_drive.h ws2812b_drive.c ws2812b_drive.h
software components: CMSIS:CORE 5.0.0, Device:Startup 8.12.0, Device:StartupConfig 8.12.0
